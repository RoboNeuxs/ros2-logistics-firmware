# Keil uVision project STM32F103C8T6.uvprojx, settings and files
target STM32F103C8T6_4Motor_AB (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: STM32F103C8T6 +hex
  c flags: Optim=3 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xB
  c include: .\Application;.\Board;.\Drivers\CMSIS\Device\Include;.\Drivers\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\MDK-ARM\STM32F103C8T6.sct
  group Startup
    ./Startup/: startup_stm32f103xb.s
  group Board
    ./Board/: motor_hal.c system_stm32f1xx.c
  group Application
    ./Application/: control_logic.c encoder.c main.c motor_driver.c parameters.c protocol.c serial_link.c
